<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\libopencm3-iar-template.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>E-Bicycle</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>E-Bicycle</project>
        <configuration>RAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


