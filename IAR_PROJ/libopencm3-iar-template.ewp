# IAR project libopencm3-iar-template.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: STM32F1; __ARM_ARCH_7M__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ; board\; ..\Driver\libopencm3\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: libopencm3-iar-template.srec
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  AARM.AUserIncludes: ; ..\src\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\src\Libraries\CMSIS\Core\CM3; ..\src\board
  group App
    ../App/: main.c
  group Driver/libopencm3/include/libopencm3/cm3
    ../Driver/libopencm3/include/libopencm3/cm3/: assert.h common.h cortex.h doc-cm3.h dwt.h fpb.h itm.h memorymap.h mpu.h nvic.h scb.h scs.h sync.h systick.h tpiu.h vector.h
  group Driver/libopencm3/include/libopencm3/dispatch
    ../Driver/libopencm3/include/libopencm3/dispatch/: nvic.h
  group Driver/libopencm3/include/libopencm3/stm32
    ../Driver/libopencm3/include/libopencm3/stm32/: adc.h can.h cec.h comparator.h crc.h crs.h dac.h dbgmcu.h desig.h dma.h ethernet.h exti.h flash.h fsmc.h gpio.h hash.h i2c.h iwdg.h memorymap.h otg_fs.h otg_hs.h pwr.h rcc.h rtc.h sdio.h spi.h syscfg.h timer.h tools.h tsc.h usart.h usb.h usb_desc.h wwdg.h
  group Driver/libopencm3/include/libopencm3/stm32/common
    ../Driver/libopencm3/include/libopencm3/stm32/common/: adc_common_v1.h crc_common_all.h crypto_common_f24.h dac_common_all.h dma_common_f24.h dma_common_l1f013.h exti_common_all.h exti_common_l1f24.h flash_common_f01.h flash_common_f234.h flash_common_f24.h gpio_common_all.h gpio_common_f234.h gpio_common_f24.h hash_common_f24.h i2c_common_all.h i2c_common_f24.h iwdg_common_all.h pwr_common_all.h rcc_common_all.h rng_common_f24.h rtc_common_l1f024.h spi_common_all.h spi_common_f03.h spi_common_f24.h spi_common_l1f124.h syscfg_common_l1f234.h timer_common_all.h timer_common_f24.h usart_common_all.h usart_common_f124.h usart_common_f24.h
  group Driver/libopencm3/include/libopencm3/stm32/f1
    ../Driver/libopencm3/include/libopencm3/stm32/f1/: adc.h bkp.h crc.h dac.h dma.h doc-stm32f1.h ethernet.h exti.h flash.h gpio.h i2c.h iwdg.h memorymap.h nvic.h pwr.h rcc.h rtc.h spi.h timer.h usart.h
  group Driver/libopencm3/include/libopencmsis
    ../Driver/libopencm3/include/libopencmsis/: core_cm3.h
  group Driver/libopencm3/include/libopencmsis/dispatch
    ../Driver/libopencm3/include/libopencmsis/dispatch/: irqhandlers.h
  group Driver/libopencm3/include/libopencmsis/stm32/f1
    ../Driver/libopencm3/include/libopencmsis/stm32/f1/: irqhandlers.h
  group Driver/libopencm3/lib/cm3
    ../Driver/libopencm3/lib/cm3/: assert.c dwt.c nvic.c scb.c systick.c vector.c
  group Driver/libopencm3/lib/stm32
    ../Driver/libopencm3/lib/stm32/: can.c desig.c
  group Driver/libopencm3/lib/stm32/common
    ../Driver/libopencm3/lib/stm32/common/: adc_common_v1.c crc_common_all.c dac_common_all.c dma_common_l1f013.c exti_common_all.c flash_common_f01.c gpio_common_all.c i2c_common_all.c iwdg_common_all.c pwr_common_all.c rcc_common_all.c spi_common_all.c spi_common_l1f124.c timer_common_all.c usart_common_all.c usart_common_f124.c
  group Driver/libopencm3/lib/stm32/f1
    ../Driver/libopencm3/lib/stm32/f1/: adc.c crc.c dac.c dma.c ethernet.c flash.c gpio.c i2c.c iwdg.c pwr.c rcc.c rtc.c spi.c timer.c usart.c vector_nvic.c
